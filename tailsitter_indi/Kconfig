## tailsitter_indi/Kconfig
```kconfig
config MODULES_TAILSITTER_INDI
	bool "tailsitter_indi"
	default n
	---help---
		Enable Tailsitter INDI Attitude Controller
```
